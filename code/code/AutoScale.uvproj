# Keil uVision project AutoScale.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AutoScale +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drv
  group Source Group 1
    ./: STARTUP.A51 main.c lcd12864.c HX711Drv.c Display.c
    ./drv/: ds1302.c iic.c
